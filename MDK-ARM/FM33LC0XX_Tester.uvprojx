# Keil uVision project FM33LC0XX_Tester.uvprojx, settings and files
target Example (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: FM33LC04X FMSH
  pack: FMSH.FM33LC0XX_DFP.3.0.2
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x6000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: FM33LC0xx_Tester +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: FM33LC0XX,__DEBUG,USE_FULL_ASSERT
  c include: ..\Drivers\CMSIS\Inculde;..\Drivers\FM33LC0xx_LL_Driver\Inc;..\Drivers\CMSIS\Device\FM\FM33xx\Include;..\MF-config\Inc;..\Inc;..\Middleware\USB\Core\inc;..\Middleware\USB\Device\inc;..\Middleware\USB\App\inc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x6000
  group Application/MDK-ARM
    ../Drivers/CMSIS/Device/FM/FM33xx/Source/Templates/ARM/: startup_fm33lc0xx.s
  group Application/MF-config
    ../MF-config/Src/: mf_config.c
  group Application/User
    ../Src/: main.c user_init.c wkup.c spi_flash.c usb.c nst112.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/FM/FM33xx/Source/: system_fm33lc0xx.c
  group Drivers/FM33LC0xx_LL_Driver
    ../Drivers/FM33LC0xx_LL_Driver/Src/: fm33lc0xx_ll_adc.c fm33lc0xx_ll_aes.c fm33lc0xx_ll_atim.c fm33lc0xx_ll_bstim.c fm33lc0xx_ll_comp.c fm33lc0xx_ll_crc.c fm33lc0xx_ll_dma.c fm33lc0xx_ll_flash.c fm33lc0xx_ll_gpio.c fm33lc0xx_ll_gptim.c fm33lc0xx_ll_hdiv.c fm33lc0xx_ll_i2c.c fm33lc0xx_ll_iwdt.c fm33lc0xx_ll_lcd.c fm33lc0xx_ll_lptim.c fm33lc0xx_ll_lpuart.c fm33lc0xx_ll_opa.c fm33lc0xx_ll_pmu.c fm33lc0xx_ll_rcc.c fm33lc0xx_ll_rng.c fm33lc0xx_ll_rtc.c fm33lc0xx_ll_spi.c fm33lc0xx_ll_svd.c fm33lc0xx_ll_u7816.c fm33lc0xx_ll_uart.c fm33lc0xx_ll_wwdt.c
  group USB/Core
    ../Middleware/USB/Core/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group USB/Device
    ../Middleware/USB/Device/src/: usbd_core.c usbd_ioreq.c usbd_req.c
  group USB/App
    ../Middleware/USB/App/src/: usb_bsp.c usbd_desc.c usbd_usr.c msc_bot.c msc_core.c msc_data.c msc_mem.c msc_scsi.c
